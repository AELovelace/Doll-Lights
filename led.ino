
const char *const CHANNEL_NAMES[CHANNELS_PER_ZONE] = {"red", "green", "blue", "white"}; // Serial labels by AnalogChannel.

void ledTest(){
    for (uint8_t zone = 0; zone < ZONE_COUNT; zone++) {
        for (uint8_t channel = RED_CHANNEL; channel <= WHITE_CHANNEL; channel++) {
            Serial.printf("Testing zone %u (%s) %s\n", zone + 1, ZONE_NAMES[zone], CHANNEL_NAMES[channel]); // Identifies the active output without a screen.

            for (int level = 0; level <= 255; level++) {
                setZoneChannel(zone, static_cast<AnalogChannel>(channel), level); // Fades one converter output up.
                delay(5);
            }

            for (int level = 255; level >= 0; level--) {
                setZoneChannel(zone, static_cast<AnalogChannel>(channel), level); // Fades the same output down.
                delay(5);
            }
        }
    }
} // Completes a red, green, blue, and white fade test of every zone in order.

void startupLightTest(){
    Serial.println("Starting Dig2Analog RGBW hardware test");
    for (uint8_t zone = 0; zone < ZONE_COUNT; zone++) {
        for (uint8_t channel = RED_CHANNEL; channel <= WHITE_CHANNEL; channel++) {
            setAllZones(0, 0, 0, 0); // Lights one output at a time so wiring order and zone order are obvious.
            setZoneChannel(zone, static_cast<AnalogChannel>(channel), 128);
            Serial.printf("Hardware test zone %u (%s) %s\n", zone + 1, ZONE_NAMES[zone], CHANNEL_NAMES[channel]);
            delay(400);
        }
    }
    setAllZones(0, 0, 0, 0); // Leaves the product safely off before network connection.
    Serial.println("Dig2Analog RGBW hardware test complete");
} // Completes a short pre-network test of every converter output in every zone.

// --- WS2814F (Dig2Analog) signal, generated by the ESP32 RMT peripheral ------------------------------
const uint32_t RMT_TICK_HZ = 10000000; // 10 MHz: one RMT tick is 0.1 us.
const uint16_t BIT1_HIGH_TICKS = 8, BIT1_LOW_TICKS = 4; // A 1 bit: 0.8 us high, 0.4 us low (800 kHz).
const uint16_t BIT0_HIGH_TICKS = 4, BIT0_LOW_TICKS = 8; // A 0 bit: 0.4 us high, 0.8 us low.
const uint32_t LATCH_GAP_US = 300; // Low time the chip needs between frames to latch the last one.
const size_t FRAME_BITS = DIG2ANALOG_BOARD_COUNT * CHANNELS_PER_ZONE * 8; // 32 bits per converter.
uint32_t zoneLastFrameUs[ZONE_COUNT] = {}; // When each zone's previous frame finished.

bool beginZoneOutput(uint8_t zone){
    return rmtInit(ZONE_DATA_PINS[zone], RMT_TX_MODE, RMT_MEM_NUM_BLOCKS_1, RMT_TICK_HZ); // The output idles low.
} // Completes the per-zone RMT channel setup; each zone keeps its own channel for its whole life.

void showZone(uint8_t zone){
    if (!zoneOutputReady[zone]) {
        return; // startPins() already reported the failure on Serial.
    }
    const uint8_t wire[CHANNELS_PER_ZONE] = {
        analogLevels[zone][WHITE_CHANNEL],
        analogLevels[zone][RED_CHANNEL],
        analogLevels[zone][GREEN_CHANNEL],
        analogLevels[zone][BLUE_CHANNEL]
    }; // The converter's W, R, G, B byte order.

    static rmt_data_t symbols[FRAME_BITS]; // One RMT symbol per bit; static keeps it off the small loop stack.
    size_t index = 0;
    for (uint16_t board = 0; board < DIG2ANALOG_BOARD_COUNT; board++) { // Mirrors the colour to each chained converter.
        for (uint8_t byteIndex = 0; byteIndex < CHANNELS_PER_ZONE; byteIndex++) {
            for (int8_t bit = 7; bit >= 0; bit--) { // Most significant bit first.
                const bool one = wire[byteIndex] & (1 << bit);
                symbols[index].level0 = 1;
                symbols[index].duration0 = one ? BIT1_HIGH_TICKS : BIT0_HIGH_TICKS;
                symbols[index].level1 = 0;
                symbols[index].duration1 = one ? BIT1_LOW_TICKS : BIT0_LOW_TICKS;
                index++;
            }
        }
    }

    while (micros() - zoneLastFrameUs[zone] < LATCH_GAP_US) {
        // Waits out the latch gap so back-to-back updates are never merged into one long frame.
    }
    if (!rmtWrite(ZONE_DATA_PINS[zone], symbols, FRAME_BITS, RMT_WAIT_FOR_EVER)) {
        Serial.printf("Zone %u frame was not sent\n", zone + 1); // Visible on USB if the RMT ever refuses.
    }
    zoneLastFrameUs[zone] = micros(); // The line now idles low, which latches this frame.
    markDisplayDirty(); // The OLED bars follow the new levels on its next refresh.
} // Completes one update of a single zone's analog strip.

void setZoneChannel(uint8_t zone, AnalogChannel channel, int level){
    analogLevels[zone][channel] = static_cast<uint8_t>(constrain(level, 0, 255)); // Guards the PWM range.
    showZone(zone); // Re-sends all four levels so this zone's unchanged channels remain steady.
} // Completes an independent RGBW channel update inside one zone.

void setZoneLevels(uint8_t zone, int red, int green, int blue, int white){
    analogLevels[zone][RED_CHANNEL] = static_cast<uint8_t>(constrain(red, 0, 255));
    analogLevels[zone][GREEN_CHANNEL] = static_cast<uint8_t>(constrain(green, 0, 255));
    analogLevels[zone][BLUE_CHANNEL] = static_cast<uint8_t>(constrain(blue, 0, 255));
    analogLevels[zone][WHITE_CHANNEL] = static_cast<uint8_t>(constrain(white, 0, 255));
    showZone(zone); // Applies the complete RGBW state in one converter update.
} // Completes an atomic update of every channel in one zone.

void setAllZones(int red, int green, int blue, int white){
    for (uint8_t zone = 0; zone < ZONE_COUNT; zone++) {
        setZoneLevels(zone, red, green, blue, white); // Each zone receives the identical color.
    }
} // Completes the same RGBW update across every zone.
